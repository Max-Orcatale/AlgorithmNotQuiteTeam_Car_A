# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\StdPeriph_Driver\Src;..\Libraries\CMSIS\startup;..\Libraries\StdPeriph_Driver\Inc;..\User\Components\flash;..\User\Components\oled;..\User\Components\ps2;..\User\Components\resource;..\User\Components\soft_i2c;..\User\Components\tracking;..\User\Components\ultrasonic;..\User\Components\y_encoder;..\User\Components\y_global;..\User\Components\y_kinematics;..\User\Components\y_led;..\User\Components\y_motor;..\User\Components\y_servo;..\User\Components\y_timer;..\User\Components\y_usart;..\User;..\User\Components\y_delay;..\User\Components
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../Libraries/StdPeriph_Driver/Inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../Libraries/StdPeriph_Driver/Src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: app_motor.c app_motor.h app_ps2.c app_ps2.h app_sensor.c app_sensor.h app_uart.c app_uart.h main.c main.h stm32f10x_conf.h
  group flash
    ../User/Components/flash/: y_flash.c y_flash.h
  group oled
    ../User/Components/oled/: y_oled.c y_oled.h
  group ps2
    ../User/Components/ps2/: y_ps2.c y_ps2.h
  group resource
    ../User/Components/resource/: resource.c resource.h
  group soft_i2c
    ../User/Components/soft_i2c/: y_soft_i2c.c y_soft_i2c.h
  group tracking
    ../User/Components/tracking/: tracking.c tracking.h
  group ultrasonic
    ../User/Components/ultrasonic/: ultrasonic.c ultrasonic.h
  group y_delay
    ../User/Components/y_delay/: y_delay.c y_delay.h
  group y_encoder
    ../User/Components/y_encoder/: y_encoder.c y_encoder.h
  group y_global
    ../User/Components/y_global/: y_global.c y_global.h
  group y_kinematics
    ../User/Components/y_kinematics/: y_kinematics.c y_kinematics.h
  group y_led
    ../User/Components/y_led/: y_led.c y_led.h
  group y_motor
    ../User/Components/y_motor/: y_motor.c y_motor.h
  group y_servo
    ../User/Components/y_servo/: y_servo.c y_servo.h
  group y_timer
    ../User/Components/y_timer/: y_timer.c y_timer.h
  group y_usart
    ../User/Components/y_usart/: y_usart.c y_usart.h
